# IAR project fw_smf_gw.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; FRDM_K64F; FREEDOM; USE_RTOS=1; PRINTF_FLOAT_ENABLE; PRINTF_ADVANCED_ENABLE; SIM_UIDH
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: Source; Source/Board; Source/Sensor; Source/Task; Source/Flash; Source/Flash/Device; Source/Interface; Source/Ethernet; Source/Ethernet/MQTT_API; Source/Ethernet/Lwip_2.0.0; Source/Ethernet/Lwip_2.0.0/port; Source/Ethernet/Lwip_2.0.0/port/arch; Source/Ethernet/Lwip_2.0.0/src; Source/Ethernet/Lwip_2.0.0/src/include; Source/Ethernet/Lwip_2.0.0/src/include/lwip; Library/CMSIS/Include; Library/devices; Library/devices/MK64F12/drivers; Library/devices/MK64F12/utilities; Library/rtos/freertos_8.2.3/Source; Library/devices/MK64F12; Library/rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; Library/rtos/freertos_8.2.3/Source/include; Source/SDCard; Source/SDCard/sdmmc; Source/SDCard/sdmmc/src; Source/SDCard/sdmmc/inc; Source/SDCard/sdmmc/port; Source/SDCard/fatfs; Source/SDCard/fatfs/option
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: Source
  OBJCOPY.OOCOutputFile: fw_smf_gw.hex
  ILINK.IlinkOutputFile: fw_smf_gw.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    Source/: AppData.h CheckMsg.c CheckMsg.h FreeRTOSConfig.h IOControl.c IOControl.h main.c main.h Parse.c Parse.h ProcessMsg.c ProcessMsg.h
  group Application/Board
    Source/Board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group Application/Interface
    Source/Interface/: RTC.c RTC.h UART.c UART.h
  group Application/SDCard
    Source/SDCard/: ffconf.h FileAccess.c FileAccess.h UserFile.c UserFile.h
  group Application/SDCard/fatfs
    Source/SDCard/fatfs/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c fsl_sd_disk.c fsl_sd_disk.h integer.h
  group Application/SDCard/sdmmc/inc
    Source/SDCard/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group Application/SDCard/sdmmc/port
    Source/SDCard/sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group Application/SDCard/sdmmc/src
    Source/SDCard/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group Application/Task
    Source/Task/: ProcessTask.c ProcessTask.h SDCardTask.c SDCardTask.h WhoAmITask.c WhoAmITask.h
  group doc
    Source/: readme.txt
  group drivers
    Library/devices/MK64F12/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_enet.c fsl_enet.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group drivers/freertos
    Library/devices/MK64F12/drivers/: fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_uart_freertos.c fsl_uart_freertos.h
  group freertos
    Library/rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    Library/rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    Library/rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    Library/rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group startup
    Library/devices/MK64F12/iar/: startup_MK64F12.s
    Library/devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group utilities
    Library/devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
